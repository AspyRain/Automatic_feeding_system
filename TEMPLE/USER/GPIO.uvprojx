# Keil uVision project GPIO.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: a +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS\CM3\CoreSupport;..\FWlib\inc;..\FWlib\src;..\USER;..\CMSIS\CM3\DeviceSupport;.\USART;.\Sys_Tick;.\GPIO;.\BPC_DECODE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c stm32f10x_conf.h define.h
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTCODE
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group DOC
    ../DOC/: README.txt
  group USART
    ./USART/: USART.c
  group GPIO
    ./GPIO/: GPIO.c
  group Sys_Tick
    ./Sys_Tick/: Sys_Tick.c
  group BPC_DECODE
    ./BPC_DECODE/: BPC_DECODE.c
